# Repository ntnunk/SmartFan

File README.md:

# Smart Fan MQTT v1

This is the very first version of the Smart Fan. It consists of:

* ESP8266 as the fan controller
* MQTT broker running on a computer on the local network
* Flask app to control the fan.

## KiCad design hw/SmartFan.kicad_pcb

Parts:
C1, C2: 1uF; CP_Radial_D4.0mm_P1.50mm; MPN CL21F105ZBFNNNE; DigikeyPN 493-15541-ND
C3: 0.1uF; CP_Radial_D6.3mm_P2.50mm; MPN CL21B104KCFNNNE; DigikeyPN 493-12624-1-ND
D1: MBR0540T1G; DO-41; MPN MBR0540T1G; Digi-Key_PN 1N5817FSCT-ND
D2, D3: 1N914BTR; DO-35; MPN 1N914BTR; Digi-Key_PN 1N914BCT-ND
J1: DISPLAY; IDC-Header_2x10_Pitch2.54mm_Straight
J2: Barrel_Jack; BarrelJack_Horizontal
J3: PWR_SW; PINHEAD1-2
J4: JTAG_SWD; IDC-Header_2x10_Pitch2.54mm_Straight
J5: Relay_Terminal; TerminalBlock_RND_205-00290_Pitch5.08mm
Q1, Q2: 2N3904; TO-92_Molded_Narrow
R1, R2, R5, R6: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R4: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: hackaBLE_0.3
U2: L7805CV; SOT-23-3; MPN L7805CV; Digi-Key_PN 497-1443-5-ND
U3: MCP23017_SP; DIP-28_W7.62mm_Socket

Connections:
+3V3: J4.1, J4.2, R1.1, R2.1, R3.1, R4.1, U1.22
+9V: J2.2, J3.2
/ANT_LED: J1.12, U3.25 (GPA4)
/BTLE_LED: J1.10, U3.24 (GPA3)
/HI_SPD_EN: J5.2, U3.1 (GPB0)
/LO_SPD_EN: J5.4, U3.3 (GPB2)
/MED_SPD_EN: J5.3, U3.2 (GPB1)
/RGB_G: J1.4, U3.23 (GPA2)
/RGB_R: J1.8, U3.21 (GPA0)
/RGB_Y: J1.6, U3.22 (GPA1)
/ROT_ENC_A: J1.9, U1.10
/ROT_ENC_B: J1.11, U1.11
/ROT_ENC_C: J1.13, U1.12
/ROT_ENC_SW1: J1.15, U1.8
/ROT_ENC_SW2: J1.17, U1.9
/SCL_3v3: D2.A, J1.3, Q1.1 (E), R1.2, U1.13
/SCL_5v: D2.K, Q1.3 (C), R5.2, U3.12 (SCK)
/SDA_3v3: D3.A, J1.1, Q2.1 (E), R2.2, U1.14
/SDA_5v: D3.K, Q2.3 (C), R6.2, U3.13 (SDA)
/SWCLK: J4.9, U1.19
/SWDIO: J4.7, U1.20
unnamed: C1.1, J3.1, U2.1 (IN)
unnamed: C2.1, C3.1, D1.A, U2.3 (OUT)
unnamed: Q1.2 (B), R3.2
unnamed: Q2.2 (B), R4.2

Notes on the sheet:
SWD Programming Port
5v Power Regulator
7-12vdc Power In
Power Flags
Display Board Port

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
Board: 2 copper layers, 93.5 x 53.3 mm, 22 parts (0 on the bottom side), 27 nets.

## Commit log

2018-07-16 Initial code commit
2018-07-16 added Git Ignore file
2018-07-16 remove build files
2018-07-16 remove tutorial
2018-07-17 First version with Scoche
2018-07-17 Bluetooth refactoring. Doesn't compile yet.
2018-07-21 v1 - MQTT and ESP8266
2018-07-22 Flask app initial commit
2018-07-22 Updates to ESP8266 firmware
2018-07-22 Added simple Python test client
2018-07-22 Cleanup
2018-07-25 ESP8266 FW
2018-07-25 MQTT Test client
2018-07-25 Flask app
2018-07-25 IMM-NRF52832 Schematic updates
2018-07-28 remove unneeded files
2018-07-28 Update to nordic
2018-07-28 Update to Nordic nRF52
2018-07-29 Nordic SDK
2018-07-29 removing build files
2018-07-30 remove ip
2018-07-30 Basic android MQTT app
2018-08-04 Hardware redesign and 1st PCB layout
2018-08-04 Updates to ignore
2018-08-04 updates to ignore file
2018-08-04 Android MQTT client
2018-08-04 Crap.
2018-08-04 removing C binaries
2018-08-04 removing android binaries
2018-08-04 ANT+ HR integration
2018-08-04 Logging updates
2018-08-06 Add Kicad backups to ignore
2018-08-06 Updated schematics and PCB
2018-08-08 Add more backups to ignore
2018-08-08 Updates to PCB layout
2018-08-12 BTLE configuration and update
2018-08-13 kind works
2018-08-14 BTLE notification update
2018-08-18 Hardware Master orphan branch initial commit
2018-08-18 remove VSCode workspace
2018-08-28 Updated ignore to include VSCode browse DB
2018-08-28 Add headers to workspace
2018-08-28 Add ARM compiler define
2019-06-07 many updates
2019-06-07 Update ignore file
2019-06-07 swapped controller for hackaBLE module
2019-06-10 mainboard updates
2019-08-26 Remove relays and associated circuitry
2019-08-29 Update to hackaBLE
2019-08-29 Simplified schematic and pcb
2019-09-17 Create BOM
2019-09-17 Final v1 updates
2019-10-12 Hardware design updates
2020-04-11 ESP32 Application processor
2020-04-11 Adding hw files
2020-10-09 Ignore compile_commands.json
2020-10-09 Update to copy compile_commands.json to app root for CCLS
2020-10-09 Based on GATT Client example. Updated to scan for HR, CPS, and CSC devices.
